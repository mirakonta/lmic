# IAR project periodic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32; TG_STK; CFG_eu868; CFG_DEBUG; CFG_wimod_board; CFG_sx1272_radio
  ICCARM.CCDiagSuppress: Pa050, Pa089
  ICCARM.CCIncludePath2: ..\..\lmic-src; ..\..\lmic-src\HAL-EFM32TG; ..\..\lmic-src\HAL-EFM32TG\emlib\inc; ..\..\lmic-src\HAL-EFM32TG\emlib\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: periodic.hex
  ILINK.IlinkOutputFile: periodic.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c sensor.c
  group LMIC
    ../../lmic-src/: aes.c hal.h lmic.c lmic.h lorabase.h oslmic.c oslmic.h radio.c
  group LMIC/HAL
    ../../lmic-src/HAL-EFM32TG/: efm32tg840f32.h efm32tg_acmp.h efm32tg_adc.h efm32tg_aes.h efm32tg_af_pins.h efm32tg_af_ports.h efm32tg_calibrate.h efm32tg_cmu.h efm32tg_dac.h efm32tg_devinfo.h efm32tg_dma.h efm32tg_dma_ch.h efm32tg_dma_descriptor.h efm32tg_dmactrl.h efm32tg_dmareq.h efm32tg_emu.h efm32tg_gpio.h efm32tg_gpio_p.h efm32tg_i2c.h efm32tg_lcd.h efm32tg_lesense.h efm32tg_lesense_buf.h efm32tg_lesense_ch.h efm32tg_lesense_st.h efm32tg_letimer.h efm32tg_leuart.h efm32tg_msc.h efm32tg_pcnt.h efm32tg_prs.h efm32tg_prs_ch.h efm32tg_prs_signals.h efm32tg_rmu.h efm32tg_romtable.h efm32tg_rtc.h efm32tg_timer.h efm32tg_timer_cc.h efm32tg_usart.h efm32tg_vcmp.h efm32tg_wdog.h em_device.h hal-efm32.c rtcdrv.c rtcdrv.h startup_efm32tg.s system_efm32tg.c system_efm32tg.h
    ../../lmic-src/HAL-EFM32TG/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
    ../../lmic-src/HAL-EFM32TG/emlib/inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_bitband.h em_burtc.h em_chip.h em_cmu.h em_common.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpio.h em_i2c.h em_idac.h em_int.h em_lcd.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_part.h em_pcnt.h em_prs.h em_rmu.h em_rtc.h em_system.h em_timer.h em_usart.h em_vcmp.h em_version.h em_wdog.h
